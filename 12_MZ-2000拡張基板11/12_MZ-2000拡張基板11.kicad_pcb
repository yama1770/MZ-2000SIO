# Repository yama1770/MZ-2000SIO

File README.md:

MZ-2000SIO拡張基板

IPLROMをMZ-2000IPL.hexに書き換える。
ｼﾘｱﾙ通信とROM起動が行える。
ROM起動は最大4個まで登録可能。
起動時に/,A,B,Dのどれかのｷｰを押すことにより選択可能。
8255はNEC制(UPD8255)を使用してください、東芝製は動作しませんでした。

## KiCad design 12_MZ-2000拡張基板11/12_MZ-2000拡張基板11.kicad_pcb

Parts:
C1, C2, C3, C16, C17, C18, C20, C30, C31, C50, C51, C52, C53, C54, C55: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
CJ1: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
IC1: DIP-28_W15.24mm_LongPads
IC2: DIP-40_W15.24mm_LongPads
IC3, IC53, IC54: 74HC138; DIP-16_W7.62mm_LongPads
IC16, IC17, IC55: 74LS273; DIP-20_W7.62mm_LongPads
IC18: 74LS245; DIP-20_W7.62mm_LongPads
IC20: 82C55A; DIP-40_W15.24mm_LongPads
IC21: Arduino_Pro_Mini
IC30, IC31: 27C512; DIP-28_W15.24mm_LongPads
IC50: 74LS139; DIP-16_W7.62mm_LongPads
IC51: 74AHC04; DIP-14_W7.62mm_LongPads
IC52: 74LS20; DIP-14_W7.62mm_LongPads
J1: MZ200_BUS_REV2
J5: Micro_SD_Card_Kit; AE-microSD-LLCNV
U3: AE-CH340-TYPEC

Connections:
/D0: IC1.25 (D0), IC2.40 (D0), IC16.3 (D0), IC17.3 (D0), IC18.18 (B0), IC20.34 (D0), IC55.3 (D0), J1.A4 (D0)
/D1: IC1.26 (D1), IC2.1 (D1), IC16.4 (D1), IC17.4 (D1), IC18.17 (B1), IC20.33 (D1), IC55.4 (D1), J1.A3 (D1)
/D2: IC1.27 (D2), IC2.39 (D2), IC16.7 (D2), IC17.7 (D2), IC18.16 (B2), IC20.32 (D2), IC55.7 (D2), J1.A2 (D2)
/D3: IC1.28 (D3), IC2.2 (D3), IC16.8 (D3), IC17.8 (D3), IC18.15 (B3), IC20.31 (D3), IC55.8 (D3), J1.B2 (D3)
/D4: IC1.1 (D4), IC2.38 (D4), IC16.13 (D4), IC17.13 (D4), IC18.14 (B4), IC20.30 (D4), IC55.13 (D4), J1.B3 (D4)
/D5: IC1.2 (D5), IC2.3 (D5), IC16.14 (D5), IC17.14 (D5), IC18.13 (B5), IC20.29 (D5), IC55.14 (D5), J1.B4 (D5)
/D6: IC1.3 (D6), IC2.37 (D6), IC16.17 (D6), IC17.17 (D6), IC18.12 (B6), IC20.28 (D6), IC55.17 (D6), J1.B5 (D6)
/D7: IC1.4 (D7), IC2.4 (D7), IC16.18 (D7), IC17.18 (D7), IC18.11 (B7), IC20.27 (D7), IC55.18 (D7), J1.B6 (D7)
/ROM1_SEL: IC51.5, IC55.5 (Q1)
/ROM2_SEL: IC51.9, IC55.6 (Q2)
/ROM_A0: IC17.2 (Q0), IC30.10 (A0), IC31.10 (A0)
/ROM_A1: IC17.5 (Q1), IC30.9 (A1), IC31.9 (A1)
/ROM_A2: IC17.6 (Q2), IC30.8 (A2), IC31.8 (A2)
/ROM_A3: IC17.9 (Q3), IC30.7 (A3), IC31.7 (A3)
/ROM_A4: IC17.12 (Q4), IC30.6 (A4), IC31.6 (A4)
/ROM_A5: IC17.15 (Q5), IC30.5 (A5), IC31.5 (A5)
/ROM_A6: IC17.16 (Q6), IC30.4 (A6), IC31.4 (A6)
/ROM_A7: IC17.19 (Q7), IC30.3 (A7), IC31.3 (A7)
/ROM_A8: IC16.2 (Q0), IC30.25 (A8), IC31.25 (A8)
/ROM_A9: IC16.5 (Q1), IC30.24 (A9), IC31.24 (A9)
/ROM_A10: IC16.6 (Q2), IC30.21 (A10), IC31.21 (A10)
/ROM_A11: IC16.9 (Q3), IC30.23 (A11), IC31.23 (A11)
/ROM_A12: IC16.12 (Q4), IC30.2 (A12), IC31.2 (A12)
/ROM_A13: IC16.15 (Q5), IC30.26 (A13), IC31.26 (A13)
/ROM_A14: IC16.16 (Q6), IC30.27 (A14), IC31.27 (A14)
/ROM_D0: IC18.2 (A0), IC30.11 (D0), IC31.11 (D0)
/ROM_D1: IC18.3 (A1), IC30.12 (D1), IC31.12 (D1)
/ROM_D2: IC18.4 (A2), IC30.13 (D2), IC31.13 (D2)
/ROM_D3: IC18.5 (A3), IC30.15 (D3), IC31.15 (D3)
/ROM_D4: IC18.6 (A4), IC30.16 (D4), IC31.16 (D4)
/ROM_D5: IC18.7 (A5), IC30.17 (D5), IC31.17 (D5)
/ROM_D6: IC18.8 (A6), IC30.18 (D6), IC31.18 (D6)
/ROM_D7: IC18.9 (A7), IC30.19 (D7), IC31.19 (D7)
/~A5: IC3.4 (~E0), IC51.4
/~IO_F8_RD: IC53.15 (~Y0)
/~IO_FA_RD: IC53.13 (~Y2)
/~IO_FA_WR: IC54.13 (~Y2), IC55.11 (Cp)
/~IO_FB_RD: IC53.12 (~Y3)
/~IO_FB_WR: IC54.12 (~Y3)
/~IO_FC_RD: IC53.11 (~Y4)
/~IO_FC_WR: IC54.11 (~Y4)
/~IO_FD_RD: IC53.10 (~Y5)
/~IO_FD_WR: IC54.10 (~Y5)
/~IO_FE_RD: IC53.9 (~Y6)
/~IO_FE_WR: IC54.9 (~Y6)
/~IO_FF_RD: IC53.7 (~Y7)
/~IO_FF_WR: IC54.7 (~Y7)
A0: IC1.18 (CS0), IC2.33 (C/~D), IC20.9 (A0), IC53.1 (A0), IC54.1 (A0), J1.A21 (A0)
A1: IC1.19 (CS1), IC2.34 (B/~A), IC20.8 (A1), IC53.2 (A1), IC54.2 (A1), J1.A20 (A1)
A2: IC3.1 (A0), IC53.3 (A2), IC54.3 (A2), J1.A19 (A2)
A3: IC3.2 (A1), IC53.6 (E2), IC54.6 (E2), J1.A18 (A3)
A4: IC3.3 (A2), IC52.1, IC52.9, J1.A17 (A4)
A5: IC51.3, IC52.2, IC52.10, J1.A16 (A5)
A6: IC3.5 (~E1), IC52.4, IC52.12, J1.A15 (A6)
A7: IC3.6 (E2), IC52.5, IC52.13, J1.A14 (A7)
A15_SEL: IC30.1 (A15), IC31.1 (A15), IC55.2 (Q0)
GND: C1.2, C2.1, C3.2, C16.2, C17.2, C18.2, C20.2, C30.2, C31.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, CJ1.2, IC1.5 (GNG), IC2.19 (~DCDA), IC2.22 (~DCDB), IC2.23 (~CTSB), IC2.31 (GND), IC3.8 (GND), IC16.10 (GND), IC17.10 (GND), IC18.10 (GND), IC20.7 (GND), IC21.4 (GND), IC21.23 (GND), IC30.14 (GND), IC31.14 (GND), IC50.8 (GND), IC51.7 (GND), IC52.7 (GND), IC53.8 (GND), IC54.8 (GND), IC55.10 (GND), J1.A5 (GND), J1.A22 (GND), J1.B13 (GND), J1.B22 (GND), J5.4 (GND), U3.6 (GND)
unnamed: IC1.13 (IEI), J1.B15 (IEI)
unnamed: IC1.11 (IEO), IC2.6 (IEI)
unnamed: IC1.7 (TO0), IC2.13 (~RXCA), IC2.14 (~TXCA)
unnamed: IC1.8 (TO1), IC2.27 (~RXTXCB)
unnamed: IC2.7 (IEO), J1.B16 (IEO)
unnamed: IC2.18 (~CTSA), U3.1 (RTS)
unnamed: IC2.17 (~RTSA), U3.5 (CTS)
unnamed: IC16.19 (Q7), IC51.11
unnamed: IC20.4 (PA0), IC21.19 (D16/A2)
unnamed: IC20.3 (PA1), IC21.20 (D17/A3)
unnamed: IC20.2 (PA2), IC21.A4
unnamed: IC20.1 (PA3), IC21.A5
unnamed: IC20.18 (PB0), IC21.5 (D2)
unnamed: IC20.19 (PB1), IC21.6 (~D3)
unnamed: IC20.20 (PB2), IC21.7 (D4)
unnamed: IC20.21 (PB3), IC21.8 (~D5)
unnamed: IC20.22 (PB4), IC21.9 (~D6)
unnamed: IC20.23 (PB5), IC21.10 (D7)
unnamed: IC20.24 (PB6), IC21.11 (D8)
unnamed: IC20.25 (PB7), IC21.12 (~D9)
unnamed: IC20.16 (PC2), IC21.18 (D15/A1)
unnamed: IC20.10 (PC7), IC21.17 (D14/A0)
unnamed: IC21.15 (D12), J5.6 (DAT)
unnamed: IC21.16 (D13), J5.5 (CLK)
unnamed: IC21.13 (~D10), J5.8 (CS)
unnamed: IC21.14 (~D11), J5.7 (CMD)
unnamed: IC30.22 (~OE), IC31.22 (~OE), IC51.10
unnamed: IC52.6, IC53.5 (~E1)
unnamed: IC52.8, IC54.5 (~E1)
RESET: IC20.35 (RESET), IC51.1, J1.B17 (RESET)
VCC: C1.1, C2.2, C3.1, C16.1, C17.1, C18.1, C20.1, C30.1, C31.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, CJ1.1, IC1.24 (VCC), IC2.9 (VCC), IC3.16 (VCC), IC16.1 (~Mr), IC16.20 (VCC), IC17.1 (~Mr), IC17.20 (VCC), IC18.1 (A->B), IC18.20 (VCC), IC20.26 (VCC), IC21.21 (VCC), IC30.28 (VCC), IC31.28 (VCC), IC50.16 (VCC), IC51.14 (VCC), IC52.14 (VCC), IC53.16 (VCC), IC54.16 (VCC), IC55.1 (~Mr), IC55.20 (VCC), J1.A1 (+5V), J1.B1 (+5V), J5.1 (5V), U3.4 (VCC)
~INT: IC1.12 (~INT), IC2.5 (~INT), J1.B19 (~EXINT)
~IORD: IC20.5 (~RD), IC50.5 (O1), IC53.4 (~E0)
~IOREQ: IC1.10 (~IORQ), IC2.36 (~IORQ), IC50.1 (E), J1.B11 (~IOREQ)
~IOWR: IC20.36 (~WR), IC50.6 (O2), IC54.4 (~E0)
~IO_A0: IC3.15 (~Y0), IC20.6 (~CS)
~IO_B0: IC1.16 (~CE), IC3.11 (~Y4)
~IO_B4: IC2.35 (~CE), IC3.10 (~Y5)
~IO_F8_WR: IC16.11 (Cp), IC54.15 (~Y0)
~IO_F9_RD: IC18.19 (CE), IC53.14 (~Y1)
~IO_F9_WR: IC17.11 (Cp), IC54.14 (~Y1)
~M1: IC1.14 (~M1), IC2.8 (~M1), J1.B8 (~M1)
~RD: IC1.6 (~RD), IC2.32 (~RD), IC50.3 (A1), J1.B10 (~RD)
~RESET: IC1.17 (~RESET), IC2.21 (~RESET), IC21.3 (RST), IC51.2
~ROM1_SEL: IC30.20 (~CE), IC51.6
~ROM2_SEL: IC31.20 (~CE), IC51.8
~WR: IC50.2 (A0), J1.B9 (~WR)
~Φ: IC1.15 (CLK), IC2.20 (CLK), J1.B7 (Φ)

Notes on the sheet:
電源はｼﾝﾎﾞﾙのPWR_FLAGと接続
CTSとDCDをGNDに落とすこと
IOｱﾄﾞﾚｽ B0 CTC0 B1 CTC1 B2 CTC2 B3 CTC3 B4 SIO Aﾃﾞｰﾀ B5 SIO Aｺﾝﾄﾛｰﾙ B6 SIO Bﾃﾞｰﾀ B7 SIO Bｺﾝﾄﾛｰﾙ MZ2000-SD IO割付 A0 PORTA 出力 下位4ﾋﾞｯﾄ A1 PROTB 入力 8ﾋﾞｯﾄ A2 PORTC Bit A3 コントロールレジスタ E0からMZ2000内部IO F8_WR EPROM A8-A14の設定 F9_WR EPROM A0-A7の設定 F9_RD EPROM D0-D7読取り ROMｾﾚｸﾄ FA 0bit A15_SEL FA 1bit ROM1_SEL FA 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
I/Oｱﾄﾞﾚｽ A0-A3

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
Board: 2 copper layers, 115.0 x 143.0 mm, 35 parts (0 on the bottom side), 95 nets.

## Commit log

2024-10-08 README.md
2024-10-08 Create LICENSE
